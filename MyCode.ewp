# IAR project MyCode.ewp, settings and files
configuration Debug (SAM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSAM8xRCRI Unspecified SAM8xRCRI
  ICCSAM8.CCIncludePath2: F:\GitHub\SAM8-Code\Head
  ICCSAM8.CCStdIncludePath: $TOOLKIT_DIR$\inc\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnksam8.xcl
  XLINK.XlinkStackSize: 1
configuration Release (SAM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSAM8xRC Unspecified SAM8xRC
  ICCSAM8.CCDefines: NDEBUG
  ICCSAM8.CCIncludePath2: F:\GitHub\SAM8-Code - 8S45\Head
  group (top)
    ./: main.c
  group Head
    Head/: 74HC164.h adc.h AT24C01.h config.h IIC.h main.h PWM.h time.h TM1629.h
  group Resource
    Resource/: 74HC164.c adc.c AT24C01.c IIC.c PWM.c time.c TM1629.c
